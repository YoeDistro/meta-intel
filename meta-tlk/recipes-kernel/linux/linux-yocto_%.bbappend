FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append = " file://time-limited-kernel.cfg"
