FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE_fishriver = "fishriver"
KMACHINE_fishriver  = "yocto/standard/fishriver"

SRCREV_machine_pn-linux-yocto_fishriver ?= "148c56415463fd34a3cc8c1953aa44a7eb935528"
SRCREV_meta_pn-linux-yocto_fishriver ?= "d386e09f316e03061c088d2b13a48605c20fb3a6"
