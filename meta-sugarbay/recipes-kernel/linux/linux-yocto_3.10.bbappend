FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

COMPATIBLE_MACHINE_sugarbay = "sugarbay"

KMACHINE_sugarbay = "sugarbay"
KBRANCH_sugarbay = "standard/common-pc-64/sugarbay"

LINUX_VERSION = "3.10.35"

SRCREV_meta_sugarbay = "7df9ef8ee47dc9023044614210f4c1d9d916dd5f"
SRCREV_machine_sugarbay = "cee957655fe67826b2e827e2db41f156fa8f0cc4"
