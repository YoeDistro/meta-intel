require meta-intel-compat-kernel.inc
