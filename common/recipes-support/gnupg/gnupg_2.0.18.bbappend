PR .= ".1"

EXTRA_OECONF += "--disable-ccid-driver"
