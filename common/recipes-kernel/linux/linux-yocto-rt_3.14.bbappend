FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

LINUX_VERSION_core2-32-intel-common = "3.14.39"
COMPATIBLE_MACHINE_core2-32-intel-common = "${MACHINE}"
SRCREV_meta_core2-32-intel-common = "36e5b5319d773f4f32d18af2b424e4c6d28eee0c"
SRCREV_machine_core2-32-intel-common = "596e72673e1318b3d72a6babf3c64908ddc8e226"
KMACHINE_core2-32-intel-common = "intel-core2-32"
KBRANCH_core2-32-intel-common = "standard/preempt-rt/base"
KERNEL_FEATURES_append_core2-32-intel-common = "${KERNEL_FEATURES_INTEL_COMMON}"

LINUX_VERSION_corei7-64-intel-common = "3.14.39"
COMPATIBLE_MACHINE_corei7-64-intel-common = "${MACHINE}"
SRCREV_meta_corei7-64-intel-common = "36e5b5319d773f4f32d18af2b424e4c6d28eee0c"
SRCREV_machine_corei7-64-intel-common = "596e72673e1318b3d72a6babf3c64908ddc8e226"
KMACHINE_corei7-64-intel-common = "intel-corei7-64"
KBRANCH_corei7-64-intel-common = "standard/preempt-rt/base"
KERNEL_FEATURES_append_corei7-64-intel-common = "${KERNEL_FEATURES_INTEL_COMMON}"
