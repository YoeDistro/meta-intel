FILESEXTRAPATHS:prepend:intel-x86-common := "${THISDIR}/${PN}:"
