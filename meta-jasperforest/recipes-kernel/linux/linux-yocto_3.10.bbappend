FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

COMPATIBLE_MACHINE_jasperforest = "jasperforest"

KMACHINE_jasperforest = "jasperforest"
KBRANCH_jasperforest = "standard/common-pc-64/jasperforest"

LINUX_VERSION = "3.10.35"

SRCREV_meta_jasperforest = "7df9ef8ee47dc9023044614210f4c1d9d916dd5f"
SRCREV_machine_jasperforest = "cee957655fe67826b2e827e2db41f156fa8f0cc4"
