IMAGE_INSTALL += "web-webkit"
IMAGE_INSTALL += "bigbuckbunny-ogg"
IMAGE_INSTALL += "ogg-cc-by-3.0-music-samples"
