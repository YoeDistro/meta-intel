IMAGE_INSTALL += "web-webkit"
IMAGE_INSTALL += "bigbuckbunny-ogg"
IMAGE_INSTALL += "ogg-CC-BY-3.0-music-samples"
